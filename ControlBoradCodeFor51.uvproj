# Keil uVision project ControlBoradCodeFor51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ControlBoradCodeFor51 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: STC8
  c include: .\Libraries\STC15_StdPeriph_Driver\inc;.\Libraries\STC15_StdPeriph_Driver\src;.\Libraries\CMSIS
  group APP
    ./Src/: main.c
    ./: ReadMe.txt
  group BSP
    ./Src/: bspDelay.c
  group STC15_StdPeriph_Driver
    ./Libraries/STC15_StdPeriph_Driver/src/: stc15xx_gpio.c stc15xx_usart.c stc15xx_timer.c
